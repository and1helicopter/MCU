# Keil uVision project prg1.uvproj, settings and files
target EK-PP-0215-12-02 (ARM-ADS)
  device: STM32F429II STMicroelectronics
  cpu: IRAM(0x20000000-0x2002FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x81FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: prg1_12_02 +hex
  c flags: Optim=3 oTime=1
  c define: EK_PP_0215_12_02
  c misc: --no_integer_literal_pools
  c include: .\STARTUP;.\PERIPH;..\PRG1;.\SOURCE
  asm include: .\STARTUP;.\SOURCE;..\PRG1
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  scatter file: .\EXEC\prg1.sct
  group STARTUP
    ./STARTUP/: startup_stm32f429_439xx.s system_stm32f4xx.c GPIOConfig12_00.c GPIOConfig12_02.c GPIO_EK_CPU_0715_03.c GPIO_EK_PP_0815_12_03.c defines.h
  group SOURCE
    ./SOURCE/: main.c Metro.c IntPrty.h StdFunc.c Menu.c menu.h Protocol.c Termodat.c
  group Listing
    ./LIST/: gpioconfig.txt main.txt pult.txt usart.txt rtc.txt extmemadc.txt metro.txt intadc.txt prg1_12_02.map fram.txt stdfunc.txt menu.txt termodat.txt oscil.txt
  group PERIPH
    ./PERIPH/: Oscil.c pult.c usart.c rtc.c IntADC.c Extmemadc.c fram.c mcan.c
  group Docs
    ./Docs/: EK-PP-0215-12-00.txt
target EK-PP-0215-12-00 (ARM-ADS)
  device: STM32F429II STMicroelectronics
  cpu: as above
  output: prg1_12_00 +hex
  c flags: Optim=4 oTime=1
  c define: EK_PP_0215_12_00
  c misc: --no_integer_literal_pools
  c include: .\STARTUP;.\PERIPH;..\PRG1;.\SOURCE
  asm include: .\STARTUP;.\SOURCE;..\PRG1
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  scatter file: .\EXEC\prg1.sct
target EK-CPU-0715-03 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F429II STMicroelectronics
  cpu: as above
  output: CPU_0715_03_Rev1 +hex
  c flags: Optim=3 oTime=1
  c define: EK_CPU_0715_03
  c misc: --no_integer_literal_pools
  c include: .\STARTUP;.\PERIPH;..\PRG1;.\SOURCE
  asm include: .\STARTUP;.\SOURCE;..\PRG1
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  scatter file: .\EXEC\prg1.sct
target EK-PP-0815-12-03 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F429II STMicroelectronics
  cpu: as above
  output: EKPP_0815_03_Rev1 +hex
  c flags: Optim=3 oTime=1 uC99=1
  c define: EK_PP_0815_12_03
  c misc: --no_integer_literal_pools
  c include: .\STARTUP;.\PERIPH;..\PRG1;.\SOURCE
  asm include: .\STARTUP;.\SOURCE;..\PRG1
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  scatter file: .\EXEC\prg1.sct
target EK-PP-0815-12-03-2 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F429II STMicroelectronics
  cpu: as above
  output: EKPP_0815_03_Rev4 +hex
  c flags: Optim=3 oTime=1
  c define: EK_PP_0815_12_03, HEAD2
  c misc: --no_integer_literal_pools
  c include: .\STARTUP;.\PERIPH;..\PRG1;.\SOURCE
  asm include: .\STARTUP;.\SOURCE;..\PRG1
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  scatter file: .\EXEC\prg1.sct
